# Keil uVision project RS485读取编码器函数.uvprojx, settings and files
target USRT (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Usrt_x +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: .\CM3;.\FWlib\inc;.\IOToggle;.\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./IOToggle/: main.c USART.h
  group FWlib
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_iwdg.c
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./startup/: startup_stm32f10x_md.s
